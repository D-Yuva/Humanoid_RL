Commit message: IK

File: PID/half_urdf/humanoidV3_half.urdf (robot description, URDF)
Before this commit: robot humanoidV3_half, 35 links, 34 joints
Joints:
- joint servo1_val: type revolute -> fixed
- joint servo2_val: type revolute -> fixed
